FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-wpa_supplicant-defconfig-enable-dbus-control-interfa.patch"

