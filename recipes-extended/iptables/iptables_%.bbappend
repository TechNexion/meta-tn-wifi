FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-xtoptions-add-error-checking-for-memory.patch"
